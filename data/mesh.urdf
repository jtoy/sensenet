Commit message: use simpler object

File: data/mesh.urdf (robot description, URDF)
Before this commit: robot jason, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=file.stl scale=0.01 0.01 0.01
